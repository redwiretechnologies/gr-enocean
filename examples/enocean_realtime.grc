options:
  parameters:
    author: Toby Flynn
    copyright: Toby Flynn 2022
    generate_options: qt_gui
    id: enocean_realtime_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bt
  id: variable
  parameters:
    value: '2'
  states: {}
- name: freq
  id: variable
  parameters:
    value: int(902.875e6)
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '62500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '625000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: 1/(samp_rate/(2*np.pi*fsk_deviation_hz))
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/(2*fsk_deviation_hz))
  states: {}
- name: sqwave
  id: variable
  parameters:
    value: (1,) * int(sps)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/tflynn/Development/enocean/enocean_cap3.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: digital_correlate_access_code_tag_xx_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '0101010101010101010100100111100'
    tagname: SOB
    threshold: '1'
    type: byte
  states: {}
- name: digital_gfsk_demod_1
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(sps)
    sensitivity: (np.pi / 2) / sps
  states: {}
- name: enocean_enocean_tag_header_to_pdu_0
  id: enocean_enocean_tag_header_to_pdu
  parameters:
    tag_name: SOB
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import filter
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
    update_time: '0.02'
  states: {}
- name: rwt_source_0
  id: rwt_source
  parameters:
    auto_filter: 'True'
    bandwidth: int(200e3)
    base_addr: '0x9D000000'
    bbdc: 'True'
    buffer_size: '32000'
    bypass_enable: 'False'
    correction_enable: 'True'
    escape: '0xAAAAAAAAAAAAAAAA'
    extra: ''
    filter: ''
    force_reload: 'False'
    freq: freq
    gain_mode: fast_attack
    manual_gain: '35.0'
    quadrature: 'True'
    rfdc: 'True'
    rfport1: A_BALANCED
    rfport2: A_BALANCED
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: (samp_rate)
    use_tags: 'True'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', digital_gfsk_demod_1, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_correlate_access_code_tag_xx_1, '0', enocean_enocean_tag_header_to_pdu_0, '0']
- [digital_gfsk_demod_1, '0', digital_correlate_access_code_tag_xx_1, '0']
- [enocean_enocean_tag_header_to_pdu_0, packet_out, blocks_message_debug_0, print]
- [rwt_source_0, '0', digital_gfsk_demod_1, '0']
- [rwt_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-119-gaa1de36b
