options:
  parameters:
    author: Toby Flynn
    copyright: '2022'
    generate_options: qt_gui
    id: packet_generator_test
    output_language: python
    title: Enocean Packet TX test
  states: {}

blocks:
- name: PacketNumber
  id: variable_qtgui_entry
  parameters:
    label: Packet_Number
    type: int
    value: '2'
  states: {}
- name: freq
  id: variable
  parameters:
    value: int(902.875e6)
  states: {}
- name: freq_deviation
  id: variable
  parameters:
    value: '62500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '625000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    value: (np.pi / 2) / sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/(2*freq_deviation))
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: Packet_Select
    target: PacketNumber
  states: {}
- name: digital_gfsk_mod_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.9'
    samples_per_symbol: '5'
    sensitivity: (2*np.pi)/(samp_rate/freq_deviation)
  states: {}
- name: enocean_enocean_packet_test_generator_0
  id: enocean_enocean_packet_test_generator
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: '3'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: push_buuton
  id: variable_qtgui_msg_push_button
  parameters:
    label: Packet_select
    msgName: sendpacket
    type: int
    value: '1'
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    size: '64'
    srate: samp_rate
    type: complex
  states: {}
- name: rwt_sink_0
  id: rwt_sink
  parameters:
    attenuation1: '30.0'
    attenuation2: '30.0'
    auto_filter: 'True'
    bandwidth: 2e6
    base_addr: '0x9D000000'
    buffer_size: '840'
    escape: '0xAAAAAAAAAAAAAAAA'
    extra: ''
    filter: ''
    force_reload: 'False'
    freq: freq
    rfport1: A
    rfport2: A
    samplerate: int(samp_rate)
    tx1_en: 'True'
    tx2_en: 'False'
    use_tags: 'True'
  states: {}

connections:
- [blocks_var_to_msg_0, msgout, enocean_enocean_packet_test_generator_0, create_packet]
- [digital_gfsk_mod_0_0, '0', qtgui_time_sink_x_3, '0']
- [digital_gfsk_mod_0_0, '0', rwt_sink_0, '0']
- [enocean_enocean_packet_test_generator_0, radio_data_out, blocks_message_debug_0, print]
- [enocean_enocean_packet_test_generator_0, radio_data_out, pdu_pdu_to_stream_x_0, pdus]
- [pdu_pdu_to_stream_x_0, '0', digital_gfsk_mod_0_0, '0']
- [push_buuton, pressed, enocean_enocean_packet_test_generator_0, create_packet]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-119-gaa1de36b
